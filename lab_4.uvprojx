# Keil uVision project lab_4.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L100RC STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: lab_4
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Source Group 1
    ./src/: interrupt_handlers.c main.c setup.c timing_functions.c interrupt_handlers.h setup.h timing_functions.h
software components: CMSIS:CORE 5.1.2, Device:Startup 2.0.0
